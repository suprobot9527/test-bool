# Keil uVision project 01_GetWay.uvprojx, settings and files
target 01_GetWay (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 01_GetWay +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Com;../Mid/FreeRTOS/include;../Mid/FreeRTOS/portable/MemMang;../Mid/FreeRTOS/portable/RVDS;../App;../Int/ETH;../Int/ETH/W5500;../Int/MQTT;../Int/MQTT/MQTTPacket/src;..\Int\MODBUS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Com
    ../Com/: Com_Debug.c Com_Delay.c cJSON.c
  group Mid/FreeRTOS
    ../Mid/FreeRTOS/portable/MemMang/: heap_4.c
    ../Mid/FreeRTOS/portable/RVDS/: port.c
    ../Mid/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group App
    ../App/: App_main.c App_Console_To_GateWay.c App_GateWay_To_Console.c
  group Int/ETH
    ../Int/ETH/: socket.c wizchip_conf.c socket.h wizchip_conf.h Int_W5500.c
    ../Int/ETH/W5500/: w5500.c w5500.h
  group Int/MQTT
    ../Int/MQTT/: mqtt_interface.c MQTTClient.c Int_MQTT.c
    ../Int/MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group Int/MODBUS
    ../Int/MODBUS/: Int_ModBus.c mbcrc.c
software components: CMSIS:CORE 4.3.0
